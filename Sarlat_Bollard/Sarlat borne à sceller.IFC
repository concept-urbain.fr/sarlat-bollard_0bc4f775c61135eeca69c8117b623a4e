Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Sarlat borne à sceller.IFC
Time: 2020-07-02T06:16:23
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0
