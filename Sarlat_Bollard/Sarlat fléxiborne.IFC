Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Sarlat fléxiborne.IFC
Time: 2020-07-02T06:16:01
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: ORMANT-737_Default
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SARL-BOR-FLE-003_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 27.8103; Area Measure: 0.846534; Volume Measure: 0.0043976
